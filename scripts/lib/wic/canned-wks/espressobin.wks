## scripts/lib/wic/canned-wks/espressobin.wks
```
part / --source rootfs --ondisk mmcblk --fstype=ext4 --label platform --align 1024

bootloader --append="root=/dev/mmcblk0p1"
```
